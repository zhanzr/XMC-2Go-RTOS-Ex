# Keil uVision project rtos_ex.uvprojx, settings and files
target XMC1100_VQFN24 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC1100-Q024x0064 Infineon
  pack: Infineon.XMC1000_DFP.2.8.0
  cpu: IROM(0x10001000,0x10000) IRAM(0x20000000,0x3FFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RTX_Blinky
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XMC1100_Q024x0064,__USE_ANSI_EXAMPLE_RAND
  memory RVCT4: ROM 0x10001000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group Source Files
    ./: main.c
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS:Keil RTX5 5.4.0, CMSIS:RTOS2:Keil RTX5 5.4.0, CMSIS Driver:USART 2.10, Device:RTE_Device 1.1.0, Device:Startup 2.1.0, Device:XMClib:GPIO 2.1.18, Device:XMClib:SCU 2.1.18, Device:XMClib:UART 2.1.18, Compiler:I/O:STDOUT 1.2.0
